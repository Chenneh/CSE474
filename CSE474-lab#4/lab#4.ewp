# IAR project lab#4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123BH6PM TexasInstruments TM4C123BH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: C:\Users\chenb24\Desktop\EE474-lab#4\header; C:\Users\chenb24\Desktop\EE474-lab#4; C:\Program Files (x86)\IAR Systems\Embedded Workbench 8.0\arm\CMSIS\Include; \\vmware-host\Shared Folders\Desktop\EE474-lab#4; \\vmware-host\Shared Folders\Desktop\EE474-lab#4\header; \\vmware-host\Shared Folders\Desktop
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: lab#4.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    header/: headerlab.h
    ./: main.c startup-lab#4.c
