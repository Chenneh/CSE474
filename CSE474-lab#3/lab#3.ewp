# IAR project lab#3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: C:\Users\chenb24\Desktop\EE474-lab#3\header; C:\Program Files (x86)\IAR Systems\Embedded Workbench 8.0\arm\CMSIS\Include; C:\Users\chenb24\Desktop\EE474-lab#3; \\vmware-host\Shared Folders\Desktop\EE474-lab#3\header
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    header/: headerlab.h
    ./: main.c startup-lab#3.c
